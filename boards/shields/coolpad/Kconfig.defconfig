## boards/shields/coolpad/Kconfig.defconfig
```kconfig
if SHIELD_COOLPAD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "coolpad"

endif
```
